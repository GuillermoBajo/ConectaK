# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: SWI.s Retarget.c
  group Source Code
    ./: main.c timer0_driver.c timer0_driver.h timer0_hal.c timer0_hal.h evento.h fifo.c fifo.h gpio.c gpio.h gpio_reserva.h io_reserva.h planificador.c planificador.h hello_world.c hello_world.h power.c power.h alarmas.c alarmas.h int_externas_hal.c int_externas_hal.h botones.c botones.h visualizar.c visualizar.h test.c test.h watchdog.c watchdog.h system_calls.c system_calls.h linea_serie_hal.c linea_serie_hal.h linea_serie_drv.c linea_serie_drv.h juego.c juego.h config_conecta_K.h conecta_K_hay_linea.s tablero.c tablero.h tablero_test.h celda.h utils.c utils.h
